<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\monster8swerve.ewp</path>
  </project>
  <batchBuild />
</workspace>
